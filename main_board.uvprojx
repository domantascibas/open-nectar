# Keil uVision project main_board.uvprojx, settings and files
target main_board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M0")
  output: main_board
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DMBED_BUILD_TIMESTAMP=1499349070.8 --split_sections -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_STM32F0 --no_rtti -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h" -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DCMSIS_VECTAB_VIRTUAL -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -DTARGET_NUCLEO_F091RC -D__CORTEX_M0 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM -DTARGET_STM32F091RC
  c include: .;src/;inc/;mbed/.;mbed/TARGET_NUCLEO_F091RC;mbed/TARGET_NUCLEO_F091RC/TARGET_STM;mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0;mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC;mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/device;mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/device;mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;DS1820/.;DS1820/OneWire;submodules/nectar_serial/src;submodules/nectar/mbed;submodules/device_menu/src;submodules/device_menu/src/Fonts;submodules/device_menu/src/Screens;submodules/device_menu/src/Screens/00;submodules/device_menu/src/Screens/01;submodules/device_menu/src/Screens/02;submodules/device_menu/src/Screens/welcome;submodules/device_menu/src/Localizations;Adafruit_GFX
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DCMSIS_VECTAB_VIRTUAL,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD/stm32f091rc.sct
  group src
    ./src/: main.cpp device_modes.cpp memory_checker.cpp Relay.cpp GridRelay.cpp SunRelay.cpp RelayController.cpp ErrorHandler.cpp TemperatureSensor.cpp TemperatureController.cpp HeaterMode.cpp DataService.cpp EnergyMeter.cpp DeviceMode.cpp
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32f091rc.o stm32f0xx_hal.o stm32f0xx_hal_adc.o stm32f0xx_hal_adc_ex.o stm32f0xx_hal_can.o stm32f0xx_hal_cec.o stm32f0xx_hal_comp.o stm32f0xx_hal_cortex.o stm32f0xx_hal_crc.o stm32f0xx_hal_crc_ex.o stm32f0xx_hal_dac.o stm32f0xx_hal_dac_ex.o stm32f0xx_hal_dma.o stm32f0xx_hal_flash.o stm32f0xx_hal_flash_ex.o stm32f0xx_hal_gpio.o stm32f0xx_hal_i2c.o stm32f0xx_hal_i2c_ex.o stm32f0xx_hal_i2s.o stm32f0xx_hal_irda.o stm32f0xx_hal_iwdg.o stm32f0xx_hal_pcd.o stm32f0xx_hal_pcd_ex.o stm32f0xx_hal_pwr.o stm32f0xx_hal_pwr_ex.o stm32f0xx_hal_rcc.o stm32f0xx_hal_rcc_ex.o stm32f0xx_hal_rtc.o stm32f0xx_hal_rtc_ex.o stm32f0xx_hal_smartcard.o stm32f0xx_hal_smartcard_ex.o stm32f0xx_hal_smbus.o stm32f0xx_hal_spi.o stm32f0xx_hal_spi_ex.o stm32f0xx_hal_tim.o stm32f0xx_hal_tim_ex.o stm32f0xx_hal_tsc.o stm32f0xx_hal_uart.o stm32f0xx_hal_uart_ex.o stm32f0xx_hal_usart.o stm32f0xx_hal_wwdg.o stm32f0xx_ll_adc.o stm32f0xx_ll_comp.o stm32f0xx_ll_crc.o stm32f0xx_ll_crs.o stm32f0xx_ll_dac.o stm32f0xx_ll_dma.o stm32f0xx_ll_exti.o stm32f0xx_ll_gpio.o stm32f0xx_ll_i2c.o stm32f0xx_ll_pwr.o stm32f0xx_ll_rcc.o stm32f0xx_ll_rtc.o stm32f0xx_ll_spi.o stm32f0xx_ll_tim.o stm32f0xx_ll_usart.o stm32f0xx_ll_utils.o stm_spi_api.o sys.o system_stm32f0xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_F091RC/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f091xc.h stm32f0xx.h system_stm32f0xx.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/: objects.h PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/device/: stm32_hal_legacy.h stm32f0xx_hal.h stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.h stm32f0xx_hal_cec.h stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.h stm32f0xx_ll_adc.h stm32f0xx_ll_bus.h stm32f0xx_ll_comp.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.h stm32f0xx_ll_crs.h stm32f0xx_ll_dac.h stm32f0xx_ll_dma.h stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.h stm32f0xx_ll_i2c.h stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.h stm32f0xx_ll_rtc.h stm32f0xx_ll_spi.h stm32f0xx_ll_system.h stm32f0xx_ll_tim.h stm32f0xx_ll_usart.h stm32f0xx_ll_utils.h stm32f0xx_ll_wwdg.h
  group inc
    ./inc/: mbed_config.h device_modes.h memory_checker.h Relay.h GridRelay.h SunRelay.h RelayController.h ErrorHandler.h TemperatureSensor.h TemperatureController.h HeaterMode.h DataService.h EnergyMeter.h DeviceMode.h
  group DS1820
    ./DS1820/: DS1820.cpp DS1820.h
    ./DS1820/OneWire/: OneWire.cpp OneWire.h
  group Adafruit_GFX
    ./Adafruit_GFX/: Adafruit_GFX.cpp Adafruit_GFX.h Adafruit_GFX_Config.h Adafruit_SSD1306.cpp Adafruit_SSD1306.h gfxfont.h glcdfont.h
  group Fonts
    ./submodules/device_menu/src/Fonts/: LargeFont.h MediumFont.h SmallFont.h XLargeFont.h
  group device menu
    ./submodules/device_menu/mbed/: menu_service.cpp screen_display.cpp screen_display.h
    ./submodules/device_menu/src/: menu_service.h
    ./submodules/device_menu/src/helpers/: helpers.h string.h time_hm.h
    ./submodules/device_menu/src/Localizations/: en.h keys.h localization.cpp localization.h lt.h
    ./submodules/device_menu/src/Screens/: ScreenModel.h
  group 00
    ./submodules/device_menu/src/Screens/00/: ConfirmationScreen.cpp ConfirmationScreen.h SetLanguageScreen.cpp SetLanguageScreen.h SetTemperatureScreen.cpp SetTemperatureScreen.h SetTimeScreen.cpp SetTimeScreen.h SetDeviceModeScreen.cpp SetDeviceModeScreen.h
  group 01
    ./submodules/device_menu/src/Screens/01/: DeviceModeScreen.h DeviceModeScreen.cpp ActiveStatusScreen.cpp ActiveStatusScreen.h ActiveTotalScreen.cpp ActiveTotalScreen.h SettingsScreen.cpp SettingsScreen.h
  group 02
    ./submodules/device_menu/src/Screens/02/: BackScreen.cpp BackScreen.h LanguageScreen.cpp LanguageScreen.h ResetScreen.cpp ResetScreen.h TemperatureScreen.cpp TemperatureScreen.h TimeScreen.cpp TimeScreen.h PairingScreen.cpp PairingScreen.h
  group Icons
    ./submodules/device_menu/src/Screens/: Icons.h
  group welcome
    ./submodules/device_menu/src/Screens/welcome/: DebugScreen.cpp DebugScreen.h IdleScreen.cpp IdleScreen.h ErrorScreen.cpp ErrorScreen.h WelcomeTimeScreen.cpp WelcomeTimeScreen.h
  group comms
    ./submodules/nectar_serial/src/: NectarStream.h NectarStream.cpp NectarContract.h
    ./src/: PowerBoardComms.cpp EspComms.cpp ServiceComms.cpp
    ./inc/: PowerBoardComms.h EspComms.h ServiceComms.h
